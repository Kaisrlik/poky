require rust-testsuite.inc
require rust-source-${PV}.inc
require rust-snapshot-${PV}.inc
